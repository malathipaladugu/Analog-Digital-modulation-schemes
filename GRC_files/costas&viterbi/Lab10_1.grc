options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: const_points
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decimator
  id: variable
  parameters:
    value: '5'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: f_cut
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: f_cut_0
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: 120e3
  states: {}
- name: fll_ntaps
  id: variable
  parameters:
    value: '55'
  states: {}
- name: interpolator
  id: variable
  parameters:
    value: '5'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 11*nfilts*sps
  states: {}
- name: rx_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts*sps,1.0,excess_bw,ntaps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 96e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_bw
  id: variable
  parameters:
    value: 2*pi/100
  states: {}
- name: tx_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1.0,excess_bw,ntaps)
  states: {}
- name: Tabs
  id: qtgui_tab_widget
  parameters:
    label0: Message before up-conversion
    label1: Up-converted Signal
    num_tabs: '2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*interpolator
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc+0.5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*interpolator
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc+0.5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*interpolator
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\shant\Desktop\lab_2024\Lab 7-20230907T064735Z-001\Lab 7\new_file_8.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abhijna/Desktop/gnuexp/lab10/solution/test.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\shant\Desktop\lab_2024\Lab 7-20230907T064735Z-001\Lab 7\a.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '2'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.001'
    init: '0'
    low: '-0.001'
  states: {state: bypassed}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.001'
    init: '0'
    low: '-0.001'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*interpolator
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*pi/100
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: fll_ntaps
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: 2*pi/100
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '16'
    loop_bw: 2*pi/100
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rx_taps
    type: ccf
  states: {}
- name: filt
  id: import
  parameters:
    imports: from gnuradio import filter
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_cut
    decim: '1'
    gain: '2'
    samp_rate: samp_rate*interpolator
    type: fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_cut
    decim: '1'
    gain: '2'
    samp_rate: samp_rate*interpolator
    type: fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: sps
    taps: tx_taps
    type: ccf
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*interpolator
    fc: '0'
    fftsize: '1024'
    gui_hint: Tabs@0
    name: '"Before Up-conversion"'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimator/sps
    fc: '0'
    fftsize: '1024'
    gui_hint: Tabs@1
    name: '"Decoded Signal"'
    showports: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*interpolator
    fc: '0'
    fftsize: '1024'
    gui_hint: Tabs@1
    name: '"Up-converted Signal"'
    showports: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: Tabs@1
    label1: ''
    size: '1024'
    srate: samp_rate/sps
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interpolator
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decimator
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1_0_0, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_1_0_0_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_1_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_sink_x_1, '0']
- [blocks_complex_to_real_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_real_1, '0', blocks_threshold_ff_0_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0, '0', blocks_skiphead_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_uchar_0_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_real_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_complex_to_real_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0, '1']
- [low_pass_filter_0_0_0, '0', blocks_float_to_complex_0, '0']
- [pfb_arb_resampler_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', digital_fll_band_edge_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
