options:
  parameters:
    generate_options: qt_gui
    id: lab8_t3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: dly
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: dly
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/saurav/Desktop/EE 340/Lab_8/output3.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/saurav/Desktop/EE 340/Lab_8/Original_Text.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_1
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '40'
    type: byte
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '40'
    type: byte
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '-0.0000001'
  states: {}
- name: blocks_threshold_ff_0_2
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '-0.0000001'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_2
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1-1j, -1+1j, 1+1j, 1-1j]'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '1'
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '8'
    taps: '1'
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    gain: '5'
    interp: '1'
    samp_rate: '400000'
    type: interp_fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '80000'
    interp: '400000'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '400000'
    interp: '80000'
    type: ccf
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '3'
    interp: '1'
    ntaps: '88'
    samp_rate: '80000'
    sym_rate: '10000'
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '3'
    interp: '1'
    ntaps: '88'
    samp_rate: '80000'
    sym_rate: '10000'
    type: interp_fir_filter_ccf
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_2, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0_2, '0']
- [blocks_add_xx_2, '0', blocks_float_to_uchar_1, '0']
- [blocks_and_xx_0, '0', blocks_uchar_to_float_0_2, '0']
- [blocks_and_xx_0_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_and_xx_0_1, '0', blocks_uchar_to_float_0_1, '0']
- [blocks_and_xx_0_1_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_1, '0', blocks_threshold_ff_0_1, '0']
- [blocks_complex_to_float_1, '1', blocks_threshold_ff_0_2, '0']
- [blocks_delay_0, '0', fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_skiphead_0_0, '0']
- [blocks_float_to_uchar_1, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_2, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_2, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_2, '3']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_2, '2']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_1, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_float_to_complex_0, '1']
- [blocks_not_xx_0, '0', blocks_and_xx_0, '0']
- [blocks_not_xx_0_0, '0', blocks_and_xx_0, '1']
- [blocks_not_xx_0_1, '0', blocks_and_xx_0_0, '0']
- [blocks_not_xx_0_1_0, '0', blocks_and_xx_0_1, '1']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_1, '0']
- [blocks_skiphead_0, '0', blocks_and_xx_0_1, '0']
- [blocks_skiphead_0, '0', blocks_and_xx_0_1_0, '0']
- [blocks_skiphead_0, '0', blocks_not_xx_0, '0']
- [blocks_skiphead_0, '0', blocks_not_xx_0_1, '0']
- [blocks_skiphead_0_0, '0', blocks_and_xx_0_0, '1']
- [blocks_skiphead_0_0, '0', blocks_and_xx_0_1_0, '1']
- [blocks_skiphead_0_0, '0', blocks_not_xx_0_0, '0']
- [blocks_skiphead_0_0, '0', blocks_not_xx_0_1_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0_2, '0', blocks_float_to_uchar_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_uchar_to_float_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_uchar_to_float_0_2, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_float_1, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', root_raised_cosine_filter_1_0, '0']
- [root_raised_cosine_filter_1, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_1_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
